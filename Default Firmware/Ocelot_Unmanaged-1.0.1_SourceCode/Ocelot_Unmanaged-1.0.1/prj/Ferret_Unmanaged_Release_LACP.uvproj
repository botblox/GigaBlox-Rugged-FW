# Keil uVision project Ferret_Unmanaged_Release_LACP.uvproj, settings and files
target F11 (MCS-51)
  device: VSC7420 Vitesse
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: Ferret_Unmanaged_F11_REL_LACP +hex
  c flags: Optimize=9
  c define: VTSS_ARCH_OCELOT FERRET_F11 PROJ_OPT=99999
  c include: c:\keil\c51\inc\winbond;..\src\config;..\src\config\proj_opt;..\src\cli;..\src\main;..\src\switch;..\src\phy;..\src\util;..\src\switch\vtss_api\base;..\src\switch\vtss_api\base\ocelot;..\src\switch\include;..\src\lldp;..\src\snmp;..\src\sw_lacp;..\src\eee;..\src\eee\base\include;..\src\fan;..\src\led;..\src\loop
  asm include: ..\src\config
  group main
    ../src/main/: uartdrv.c timer.c interrupt.c main.c sysutil.c event.c STARTUP_OCELOT.A51 vtss_os.c i2c_h.c i2c.c
  group switch
    ../src/switch/: txrxtst.c h2flowc.c h2ioutil.c h2mactab.c h2txrx.c h2vlan.c h2.c h2io.a51 h2fan.c h2eee.c h2pcs1g.c h2sdcfg.c h2stats.c h2gpios.c h2txrxaux.c h2aggr.c h2e2etc.c h2mailc.c h2tcam.c
  group cli
    ../src/cli/: txt.c print.c clihnd.c txt_moredef.c
  group phy
    ../src/phy/: phytsk.c phymap.c phydrv.c veriphy.c phy_base.c phy_atom12.c phy_tesla.c phy_elise.c phy_spyder.c phy_quattro.c phy_enzo.c phy_cobra.c
  group config
    ../src/config/: version.c hwport.c spiflash.c
  group util
    ../src/util/: misc1.c misc2.a51 misc3.a51
  group lldp
    ../src/lldp/: lldp.c lldp_os.c lldp_remote.c lldp_sm.c lldp_tlv.c
  group snmp
    ../src/snmp/: mib_common.c
  group lacp
    ../src/sw_lacp/: vtss_lacp.c
  group eee
    ../src/eee/: eee.c
    ../src/eee/base/: eee_base.c
  group fan
    ../src/fan/: fan.c
  group led
    ../src/led/: ledtsk.c
  group loop
    ../src/loop/: loopdet.c
target F10P (MCS-51)
  device: VSC7420 Vitesse
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: Ferret_Unmanaged_F10P_REL_LACP +hex
  c flags: Optimize=9
  c define: VTSS_ARCH_OCELOT FERRET_F10P PROJ_OPT=99999
  c include: as above
  asm include: ..\src\config
target F5 (MCS-51)
  device: VSC7420 Vitesse
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: Ferret_Unmanaged_F5_REL_LACP +hex
  c flags: Optimize=9
  c define: VTSS_ARCH_OCELOT FERRET_F5 PROJ_OPT=99999
  c include: as above
  asm include: ..\src\config
target F4P (MCS-51)
  device: VSC7420 Vitesse
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(24000000)
  output: Ferret_Unmanaged_F4P_REL_LACP +hex
  c flags: Optimize=9
  c define: VTSS_ARCH_OCELOT FERRET_F4P PROJ_OPT=99999
  c include: as above
  asm include: ..\src\config
